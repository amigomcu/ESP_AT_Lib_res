# IAR project project.ewp, settings and files
configuration STM32L496G_Discovery_Netconn_Server_RTOS (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx; STM32L4xx; USE_FULL_LL_DRIVER; STM32F769_DISCOVERY
  ICCARM.CCIncludePath2: ../inc; ../../../../src/include; ../../../../snippets/include; ../../../../libs; ../../../../libs/st_hal/STM32L4xx_HAL_Driver/Inc; ../../../../libs/st_hal/CMSIS/Device/ST/STM32L4xx/Include; ../../../../libs/st_hal/CMSIS/Include; ../../../../libs/FreeRTOS/include; ../../../../libs/FreeRTOS/CMSIS_RTOS; ../../../../libs/FreeRTOS/; ../../../../libs/FreeRTOS/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../inc
  OBJCOPY.OOCOutputFile: NETCONN Server RTOS.srec
  ILINK.IlinkOutputFile: NETCONN Server RTOS.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ESP API
    ../../../../ESP_AT_Lib/src/api/: esp_netconn.c
  group ESP CORE
    ../../../../ESP_AT_Lib/src/esp/: esp.c esp_ap.c esp_buff.c esp_conn.c esp_debug.c esp_evt.c esp_hostname.c esp_input.c esp_int.c esp_mem.c esp_parser.c esp_pbuf.c esp_ping.c esp_sntp.c esp_sta.c esp_threads.c esp_timeout.c esp_unicode.c esp_wps.c
  group ESP LL
    ../../../../ESP_AT_Lib/src/system/: esp_ll_stm32l496g_discovery.c esp_sys_cmsis_os.c
  group ESP SNIPPETS
    ../../../../snippets/: netconn_server.c station_manager.c
  group FreeRTOS
    ../../../../libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
    ../../../../libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../libs/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group STM32L4xx_HAL_Drivers
    ../../../../libs/st_hal/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
  group User
    ../src/: main.c stm32l4xx_it.c system_stm32l4xx.c
    ./: startup_stm32l496xx.s
