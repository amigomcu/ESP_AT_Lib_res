# Keil uVision project netconn_server_rtos.uvprojx, settings and files
target Netconn_Server_RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Netconn_Server_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F723xx
  c include: ..\inc;..\..\..\..\libs;..\..\..\..\libs\st_hal\STM32F7xx_HAL_Driver\Inc;..\..\..\..\libs\st_hal\CMSIS\Include;..\..\..\..\libs\st_hal\CMSIS\Device\ST\STM32F7xx\Include;..\..\..\..\libs\FreeRTOS\CMSIS_RTOS;..\..\..\..\libs\FreeRTOS\include;..\..\..\..\libs\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\..\..\..\snippets\include;..\..\..\..\ESP_AT_Lib\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group MDK-ARM
    ./: startup_stm32f723xx.s
  group CMSIS
    ../Src/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../../../libs/st_hal/STM32F7xx_HAL_Driver/Src/: stm32f7xx_ll_dma.c stm32f7xx_ll_exti.c stm32f7xx_ll_gpio.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_usart.c stm32f7xx_ll_utils.c
  group FreeRTOS
    ../../../../libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../libs/FreeRTOS/portable/RVDS/ARM_CM7/: port_cm7.c
    ../../../../libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
  group ESP CORE
    ../../../../ESP_AT_Lib/src/esp/: esp.c esp_ap.c esp_buff.c esp_conn.c esp_debug.c esp_evt.c esp_hostname.c esp_input.c esp_int.c esp_mem.c esp_parser.c esp_pbuf.c esp_ping.c esp_sntp.c esp_sta.c esp_threads.c esp_timeout.c esp_unicode.c esp_wps.c
  group ESP API
    ../../../../ESP_AT_Lib/src/api/: esp_netconn.c
  group ESP LL
    ../../../../ESP_AT_Lib/src/system/: esp_sys_cmsis_os.c esp_ll_stm32f723e_discovery.c
  group ESP SNIPPETS
    ../../../../snippets/: station_manager.c netconn_server.c
  group User
    ../Src/: stm32f7xx_it.c main.c
