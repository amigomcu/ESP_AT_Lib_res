# IAR project esp_dev_rtos.ewp, settings and files
configuration esp_dev_rtos (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; STM32F7xx; USE_FULL_LL_DRIVER; STM32F769_DISCOVERY
  ICCARM.CCIncludePath2: ../include; ../../src/include; ../../snippets/include; ../../libs; ../../libs/st_hal/STM32F7xx_HAL_Driver/Inc; ../../libs/st_hal/CMSIS/Device/ST/STM32F7xx/Include; ../../libs/st_hal/CMSIS/Include; ../../libs/FreeRTOS/include; ../../libs/FreeRTOS/CMSIS_RTOS; ../../libs/FreeRTOS/; ../../libs/FreeRTOS/portable/IAR/ARM_CM7/r0p1; ../../libs/fatfs; ../../libs/fatfs/drivers/; ../../libs/option
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../include
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: esp_dev_rtos.out
  ILINK.IlinkIcfFile: stm32f769xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ESP API
    ../../ESP_AT_Lib/src/api/: esp_netconn.c
  group ESP CORE
    ../../ESP_AT_Lib/src/esp/: esp.c esp_ap.c esp_buff.c esp_conn.c esp_debug.c esp_evt.c esp_hostname.c esp_input.c esp_int.c esp_mem.c esp_parser.c esp_pbuf.c esp_ping.c esp_sntp.c esp_sta.c esp_threads.c esp_timeout.c esp_unicode.c esp_wps.c
  group ESP HTTP SERVER
    ../../ESP_AT_Lib/src/apps/http_server/: esp_http_server.c esp_http_server_fs.c esp_http_server_fs_fat.c
  group ESP LL
    ../../ESP_AT_Lib/src/system/: esp_ll_stm32f769i_discovery.c esp_sys_cmsis_os.c
  group ESP MQTT CLIENT
    ../../ESP_AT_Lib/src/apps/mqtt/: esp_mqtt_client.c
  group ESP SNIPPETS
    ../../snippets/: http_server.c mqtt_client.c netconn_client.c netconn_server.c station_manager.c
  group FreeRTOS
    ../../libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
    ../../libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../../libs/FreeRTOS/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group STM32F7_HAL_Drivers
    ../../libs/st_hal/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_dma.c stm32f7xx_ll_gpio.c stm32f7xx_ll_rcc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usart.c
  group TM
    ../../libs/: tm_stm32_buffer.c tm_stm32_delay.c tm_stm32_disco.c tm_stm32_general.c tm_stm32_gpio.c tm_stm32_rcc.c tm_stm32_usart.c
  group User
    ../src/: main.c stm32fxxx_it.c system_stm32f7xx.c
    ./: startup_stm32f769xx.s
